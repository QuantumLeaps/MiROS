# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32C031C6 ST STM32C031C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32C031xx
  ICCARM.CCIncludePath2: ..; ..\..\..\include; ..\..\..\3rd_party\CMSIS\Include; ..\..\..\3rd_party\nucleo-c031c6
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32C031xx
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: project.srec
  group (top)
    ../: bsp.c bsp.h main.c
  group MiROS
    ../../../src/iar/: miros.c
    ../../../include/: miros.h
  group nucleo-c031c6
    ../../../3rd_party/nucleo-c031c6/iar/: startup_stm32c031xx.s
    ../../../3rd_party/nucleo-c031c6/: system_stm32c0xx.c system_stm32c0xx.h
