# Keil uVision project project.uvprojx, settings and files
target dbg (6160000::V6.16::ARMCLANG)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x14000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..;..\..\..\include;..\..\..\3rd_party\CMSIS\Include;..\..\..\3rd_party\nucleo-l152re
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --entry Reset_Handler
  group Application
    ../: bsp.h bsp.c main.c
  group nucleo-l152re
    ../../../3rd_party/nucleo-l152re/: stm32l1xx.h system_stm32l1xx.c
    ../../../3rd_party/nucleo-l152re/arm/: startup_stm32l1xx.s
  group MiROS
    ../../../src/armclang/: miros.c
    ../../../include/: miros.h
target rel (6160000::V6.16::ARMCLANG)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: as above
  output: project
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\project.bin .\rel\project.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --entry Reset_Handler
