# Keil uVision project blinky-tm4c.uvprojx, settings and files
target dbg (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky-tm4c
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .;..\..\inc;..\..\3rd_party\CMSIS\Include;..\..\3rd_party\ek-tm4c123gxl
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Applicatioin
    ./: bsp.c main.c bsp.h
  group ek-tm4c123gxl
    ../../3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c TM4C123GH6PM.h
    ../../3rd_party/ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
  group MiROS
    ../../src/: MiROS.c
    ../../inc/: MiROS.h
